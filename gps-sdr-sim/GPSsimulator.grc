options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: GPS generator
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: Baseband Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '20'
  states: {}
- name: freq
  id: variable
  parameters:
    value: ' 1575420000'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '14'
    value: '12'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.6e6
  states: {}
- name: blocks_file_source_0_1_0
  id: blocks_file_source
  parameters:
    file: /home/ado/Escritorio/GPS-SPOOFING/gps-sdr-sim/ruta.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_1_0_0
  id: blocks_file_source
  parameters:
    file: /home/ado/Escritorio/TFG GPS/gps-sdr-sim/gpssim.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: BAND1
    args: hackrf=0
    bb_gain0: bb_gain
    freq0: freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_sink_0_0_0
  id: osmosdr_sink
  parameters:
    ant0: BAND1
    args: hackrf=1
    bb_gain0: bb_gain
    freq0: ' 1595420000'
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {state: disabled}

connections:
- [blocks_file_source_0_1_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_file_source_0_1_0_0, '0', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', osmosdr_sink_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', osmosdr_sink_0_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
